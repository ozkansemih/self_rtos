# Keil uVision project self_freertos.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: self_freertos
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER , HSE_VALUE = 8000000
  c include: .\freertos\include;.\freertos\portable\RVDS\ARM_CM4F;.\periph\inc;.\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group 1
    ./: main.c main.h
  group freeRTOS
    ./freertos/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ./freertos/portable/RVDS/ARM_CM4F/: port.c
    ./freertos/portable/MemMang/: heap_4.c
  group sePeriph
    ./periph/src/: se407_DMA.c se407_GPIO.c se407_RNG.c se407_TIM.c se407_USART.c se407_SPI.c
  group src
    ./src/: delayy.c init_clock.c leds.c PCDD8544.c
software components: CMSIS:CORE 5.5.0, Device:Startup 1.3.1, Device:StdPeriph Drivers:DMA 1.3.0, Device:StdPeriph Drivers:EXTI 1.3.0, Device:StdPeriph Drivers:Framework 1.3.1, Device:StdPeriph Drivers:GPIO 1.3.0, Device:StdPeriph Drivers:RCC 1.3.0, Device:StdPeriph Drivers:RNG 1.3.0, Device:StdPeriph Drivers:SPI 1.3.0, Device:StdPeriph Drivers:SYSCFG 1.3.0, Device:StdPeriph Drivers:TIM 1.3.0, Device:StdPeriph Drivers:USART 1.3.0
